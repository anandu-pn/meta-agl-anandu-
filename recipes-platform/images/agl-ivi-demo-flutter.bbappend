# Include the AGL Quiz App in the AGL IVI Demo Flutter image
IMAGE_INSTALL:append = " agl-quiz-app"
